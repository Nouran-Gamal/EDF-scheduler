# Keil uVision project 1st_project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 1st_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sprints_ARM_C02\src\Common;.\Sprints_ARM_C02\src\Config;.\Sprints_ARM_C02\src\Mcal\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Appl
    ./Sprints_ARM_C02/src/Appl/: main.c
  group Config
    ./Sprints_ARM_C02/src/Config/: IntCtrl_Lcfg.c
  group Mcal
    ./Sprints_ARM_C02/src/Mcal/: IntCtrl.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
